# Keil uVision project ICAPTURE.uvprojx, settings and files
target ICAPTURE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ICAPTURE +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\CONTROL;..\HARDWARE\DataScope_DP;..\HARDWARE\DMP;..\HARDWARE\ENCODER;..\HARDWARE\EXTI;..\HARDWARE\filter;..\HARDWARE\IIC;..\HARDWARE\MOTOR;..\HARDWARE\MPU6050;..\HARDWARE\OLED_IIC;..\HARDWARE\show;..\HARDWARE\STMFLASH;..\HARDWARE\USART3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c system_stm32f10x.c
  group HARDWARE
    ./: stm32f10x_it.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/DataScope_DP/: DataScope_DP.C
    ../HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/filter/: filter.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/OLED_IIC/: oled.c
    ../HARDWARE/show/: show.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dac.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c stm32f10x_adc.c
  group README
    ../: README.TXT
